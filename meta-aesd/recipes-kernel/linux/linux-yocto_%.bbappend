FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://kmem_dbg.cfg"
